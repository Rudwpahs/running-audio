## m0_rx/sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_HZ=1000
CONFIG_ESP_WIFI_NVS_ENABLED=y
CONFIG_LWIP_MAX_SOCKETS=10
CONFIG_LOG_DEFAULT_LEVEL_INFO=y
```
